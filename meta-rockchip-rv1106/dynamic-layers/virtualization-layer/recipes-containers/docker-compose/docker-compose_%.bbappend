# Used as the `podman compose` provider through podman's Docker-compatible API
# socket. Install it on PATH instead of as a docker CLI plugin, which would
# pull in the docker engine.
PACKAGECONFIG = ""
